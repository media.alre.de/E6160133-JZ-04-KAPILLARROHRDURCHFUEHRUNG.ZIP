Properties of the parts of a building model (IFC2X3)

# File
Description: Kapillarrohr-Durchführung für Frostschutzthermostate JTF und Kapillarregler JMT/WR/JET, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: E6160133, Kapillarrohr-Durchführung für Frostschutzthermostate JTF und Kapillarregler JMT/WR/JET
In: Raum
Description: Kapillarrohrdurchführung für Luftkanäle mit 30 cm Schutzschlauch für Frostschutzthermostate JTF und Kapillarregler JMT/WR/JET; Classification: EC011349 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: E6160133; ModelLabel: JZ-04; GlobalTradeItemNumber: 4050528031617; ProductURL: https://alre.de/produkt_E6160133
Pset_Specification - NominalLength: 0.3 m; NominalWidth: 0.006 m; NominalDepth: 0.006 m; NetWeight: 0.012
Pset_ALRE_ETIM_Properties - Art des Zubehörs/Ersatzteils: Durchführstück; Zubehör: yes; ETIM-Klasse: EC011349; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-E6160133.pdf
